## Kconfig
```kconfig
menu "Deadkey Slayer Options"

config ZMK_DEADKEY_SLAYER
    bool "Enable Deadkey Slayer"
    default y

endmenu
```
